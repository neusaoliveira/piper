# IAR project Backup (2) of driverlib-cm3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: driverlib-cm3.srec
  ILINK.IlinkOutputFile: driverlib-cm3.out
  group Source
    ./: adc.c can.c comp.c cpu.c epi.c ethernet.c flash.c gpio.c hibernate.c i2c.c i2s.c interrupt.c mpu.c pwm.c qei.c ssi.c sysctl.c systick.c timer.c uart.c udma.c usb.c watchdog.c
