# IAR project Backup (2) of ucp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..; ..\..\lwip\apps; ..\..\lwip\ports\stellaris\include; ..\..\lwip\src\include; ..\..\lwip\src\include\ipv4; ..\..\lwip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ctrl.bin
  ILINK.IlinkOutputFile: xplane.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers
    ../../drv/: rit128x96x4.c
  group Ethernet
    ../../app/eth/: eth_udp.c
  group Guidance
    ../../app/gdn/: gdn.c
  group Libraries
    ../../lib/ewarm-cm3/Exe/: driverlib.a
  group Services
    ../../utl/: crc.c math.c
    ../../srv/: display.c pid.c wof.c
    ../../lib/utils/: lwiplib.c uartstdio.c ustdlib.c
    ../../etc/: system.c
  group Source
    ./: main.c startup.c
